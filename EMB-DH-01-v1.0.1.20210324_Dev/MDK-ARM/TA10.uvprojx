# Keil uVision project TA10.uvprojx, settings and files
target TA10 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F303VDTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x00060000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EMB-DH-01-11 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_NUCLEO,STM32F30X,USE_USB_OTG_FS,ARM_MATH_CM4,__FPU_PRESENT =1,__FPU_USED=1,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,STM32F303xE,__TARGET_FPU_VFP
  c misc: --C99
  c include: ../inc;../../../Libraries/STM32_USB-FS-Device_Driver/inc;../../../Utilities/STM32_EVAL;../../../Utilities/STM32_EVAL/Common;..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F30x_StdPeriph_Driver\src;..\..\..\..\..\usb-com\usb\Drivers\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include;..\..\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\MDK-ARM;..\Periphal\inc;..\algorithm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USB-FS-Driver
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
    ../src/: usb_endp.c usb_desc.c usb_pwr.c usb_prop.c usb_istr.c
  group User
    ../src/: stm32_it.c main.c hw_config.c
  group StdPeriph_Driver
    ../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group system
    ../src/: system_stm32f30x.c
  group Lib
    ../lib/: arm_cortexM4lf_math.lib M4_CryptoFW_2_0_6.lib
  group Periphal
    ../Periphal/src/: analog_switch.c dac.c delay.c Encrypt.c filter.c flash.c led.c peripheral.c protocal.c
  group Startup
    ../startup/: startup_stm32f30x.s
software components: CMSIS:CORE 5.4.0
